# Repository jj1iyu/coax-relay-switch

File README.md:

# coax-relay-switch

PCのブラウザ（Chrome / Edge）から、USB接続した **RP2040-Zero** を介して **12V同軸リレー** を切り替える制御基板です。
実家に置いたアンテナ切り替え器を、リモートデスクトップ経由で操作する用途で作っています（HF用）。

```
PC (Chrome)  ──USB(Web Serial)──  RP2040-Zero  ──GP2──▶  12Vハイサイドスイッチ  ──▶  Fコネクタ  ──▶  同軸リレー
                                       ▲
                                       └─GP26(ADC)── 12V電圧監視
```

- 操作ページ: https://jj1iyu.github.io/coax-relay-switch/ （GitHub Pages。Chrome / Edge を単独のタブで開く）
- リレー非通電 = **ANT A**、通電 = **ANT B**。起動・リセット・USB断のときは必ず ANT A
- アンテナ名は操作ページの「設定・保守」で自由に変えられる（このブラウザに保存され、ボタンとログに反映）

| 内容 | 場所 |
|---|---|
| ファームウェア（Arduino / Arduino-Pico） | [`firmware/coax_relay_ctrl/`](firmware/coax_relay_ctrl/) |
| 操作ページ（Web Serial） | [`docs/index.html`](docs/index.html) |
| 回路図・基板（KiCad、JLCPCB用ガーバー） | [`hardware/`](hardware/) |
| 3Dプリント用ケース（OpenSCAD / STL） | [`case/`](case/) |

## 回路の概要（rev0.3。回路は rev0.2 と同じで、部品配置だけ変更）

回路図: [`hardware/schematic.pdf`](hardware/schematic.pdf)

1. **電源入力** — DCジャック J1（MJ-179PH, センター＋）→ ポリスイッチ F1（MF-R050, 0.5A）→ 1N5819 D1（逆接保護）→ +12V。C1 100µF / C2 0.1µF。
2. **12V監視** — R3 47k / R4 10k で約1/5.7に分圧し GP26(ADC0) で読む。C3 0.1µF。
3. **マイコン** — RP2040-Zero を 1×9 ピンソケット2本に挿す。PCの USB から給電。基板の12V系とは GND のみ共通。
4. **12V出力スイッチ（ハイサイド）** — GP2=H → R1 1k → Q1 2SC1815 ON → Q2（Pch MOSFET IRFU9024N）のゲートを GND へ → Q2 ON → OUT=12V。
   GP2=L・起動前・リセット中は R2 10k が Q1 を、R7 10k が Q2 を OFF に保つ。
5. **出力** — 端子台 J4 → ケースの F-J（中心=12V、外側=GND）→ 同軸リレー。D2（1N5819）でコイルの逆起電力を吸収、LED1（R5 4.7k）は出力中に点灯（ケース前面から見える）。

Fコネクタはシールドが常に GND なので、中心導体（12V 側）を切り替えるハイサイド方式にしています。

### 部品（主なもの・秋月電子）

| 記号 | 部品 |
|---|---|
| U1 | Waveshare RP2040-Zero（1×9 ピンソケット ×2 に挿す） |
| J1 | 2.1mm DCジャック MJ-179PH |
| F1 | リセッタブルヒューズ MF-R050 |
| D1, D2 | 1N5819（D2 は 1N4148 でも可） |
| Q1 / Q2 | 2SC1815 / IRFU9024N |
| R1 / R2,R4,R7 / R3 / R5 | 1k / 10k / 47k / 4.7k（1/4W） |
| C1 / C2,C3 | 100µF 25V以上 / 0.1µF |
| J4 | ターミナルブロック 2P 5.08mm |
| — | F-J シャーシ用（ケースに取付）、12V ACアダプター |

## ファームウェア

- Arduino IDE ＋ [Arduino-Pico](https://github.com/earlephilhower/arduino-pico)（ボード: *Waveshare RP2040 Zero*）。ESP32 でもピン定義を切り替えて動く。
- 版は `FW_VERSION`（`firmware/coax_relay_ctrl/coax_relay_ctrl.ino` の先頭）。変更したら必ず上げる。
- **自動ビルド**: `firmware/` を変更して push すると GitHub Actions がビルドし、`docs/firmware/coax_relay_ctrl.uf2` と `version.json` を更新する。操作ページはこれを見て「更新あり」を出す。
- 初回（v0.2 以前からの更新）だけは、BOOT を押しながら RESET（または USB 挿入）で RPI-RP2 ドライブを出して書き込む。

シリアルコマンド（115200bps、行末 LF、大文字小文字は区別しない）:

| コマンド | 動作 | 応答 |
|---|---|---|
| `ON` / `OFF` | 出力 ON（ANT B）/ OFF（ANT A） | `STATE ON VIN 12.10 UP 35` |
| `?` | 状態の問い合わせ | `STATE ON/OFF VIN xx.xx UP n` |
| `VER` | 版と校正値 | `VER 0.3.0 CAL 1.0245` |
| `CAL 12.12` | テスターで測った 12V 入力の実測値で校正（フラッシュに保存） | `CAL OK 1.0245` |
| `CAL RESET` | 校正値を 1.0 に戻す | `CAL OK 1.0000` |
| `BOOTSEL` | 書き込みモード（RPI-RP2 ドライブ）で再起動。BOOT ボタン不要 | `BOOTSEL` |

`UP` は起動からの秒数。起動時に `BOOT 0.3.0` を送る。制御文字は無視する。

## 操作ページ

- GitHub Pages（上記URL）か、`docs/` で `python -m http.server` を実行して `http://localhost:8000/` を Chrome / Edge で開く。
- **単独のタブで開くこと。** 他のページへの埋め込み表示（プレビュー等）では `permissions policy` で Web Serial が使えない。
- 「接続」で RP2040-Zero の COM ポートを選ぶ。一度許可したポートには次回から自動接続し、USB が抜けて再び現れたときも自動で再接続する。
- COM ポートは同時に1つのソフトしか開けない（zLog・wfview・シリアルモニタと競合させない）。

### 設定・保守（ページ下部の「設定・保守」欄）

- **アンテナ名**: A（非通電）・B（通電）に好きな名前を付けて「保存」。ボタンとログがその名前になる。名前はそのブラウザ（localStorage）に保存されるので、実家PCの Chrome で一度設定すればよい。空欄・「初期値に戻す」で ANT A / ANT B。
- **版の確認**: 接続するとマイコンの版と、公開中の最新版を表示。新しい版があれば「更新あり」。
- **ファームウェア更新（リモートデスクトップ越しでも可）**:
  1. 「① 書き込みモードにする」→ 最新の .uf2 を取得し、マイコンを RPI-RP2 ドライブとして再起動（出力は OFF）
  2. 「② RPI-RP2 を選んで書き込む」→ ブラウザのフォルダ選択で RPI-RP2 ドライブを選ぶと .uf2 を書き込む
  3. マイコンが再起動し、ページが自動で再接続して新しい版を表示
  - ②でドライブを選べない場合は、「.uf2 をダウンロード」してエクスプローラーで RPI-RP2 にコピーする。
- **電圧の校正**: テスターで測った 12V 入力の値を入れて「校正」。校正値はマイコンに保存され、書き込み直しても消えない。

## 動作確認チェックリスト

| 確認 | 操作 | 期待する結果 |
|---|---|---|
| 接続 | 「接続」→ COM ポート | 「接続中」、2秒ごとに電圧表示が更新 |
| ANT B / ANT A | ボタン | LED 点灯・OUT≈12V / LED 消灯・OUT 0V |
| 電圧表示 | 12V を入れる / 抜く | 実測とほぼ同じ / 0V付近で赤表示 |
| リセット | RP2040-Zero の RESET | USB が一度切れ、自動再接続後「マイコン再起動を検出（ANT A）」 |
| 校正 | 設定・保守欄でテスターの実測値を入れて「校正」 | 電圧表示が実測値と一致し、再起動後も保たれる |
| 更新 | 設定・保守欄の ①→② | 再起動後に自動再接続し、マイコンの版が最新版と一致 |
| 起動時の出力 | ANT B のまま USB を挿し直す | 挿した瞬間も LED は点かず OUT 0V |

## 基板（hardware/）— rev0.3

- **コネクタはすべて前の辺に集めた**（外から見て左から）: USB-C（RP2040-Zero）｜DCジャック J1｜LED1｜F-J（J4 の正面、ケース前面に取付）。
- KiCad プロジェクト（KiCad 7 形式。KiCad 8〜10 で開ける）。66 × 46mm、2層、M3 取付穴 4隅（端から 3.5mm）。
- JLCPCB にはガーバー zip（`hardware/coax_relay_gerber_JLCPCB.zip`）をそのままアップロード（2層・1.6mm）。
- 組み立てのポイント:
  - RP2040-Zero は USB-C を前（基板の辺側）に向けて挿す。ソケットは高さ 12mm（基板上面〜RP2040-Zero の下面）の実測値でケースを設計している。
  - LED1 は足を約 3mm 残して 90° 前へ曲げ、LED の中心が基板上面から約 2.8mm、先端が基板の辺から 1〜2mm 出るようにはんだ付けする（ケース前面の穴に差し込む）。長い足（アノード）は丸パッド側。
  - J4 の正面（基板の辺から 13mm の範囲）は F-J の内側ナットと配線用に部品を置いていない。
- `hardware/scripts/` は回路図・基板を生成したスクリプト（参考。パスは作成環境のもの）。
- 発注前に実物で確認: RP2040-Zero のピン配置（USB を上にして左列 5V/GND/3V3/GP29…、右列 GP0…GP8）、MJ-179PH の穴位置（1:1 印刷で当てる）。

## ケース（case/）— rev0.3

- `coax_relay_case_body.stl` / `coax_relay_case_lid.stl` をそのまま印刷（PLA / PETG）。本体は開口を上、フタは表面を下にすれば**サポート不要**。
  - 45°を超えるオーバーハングは、前面の穴（USB 開口・座ぐりの上辺 13.5〜16mm のブリッジ、DC φ10・F-J φ9.8・LED φ3.3 の上辺）と刻印文字だけ。
  - フタ固定ボスの下面は約45°の斜面。
- 外形 約 71.8 × 53.6 × 34mm（フタ込み 36mm）。rev0.2 より 6mm 高くし、USB プラグの上にフタのリップまで 3mm の余裕がある（rev0.2 では USB とフタが干渉した）。
- 穴は前面だけ。背面・側面・フタには穴なし。フタには「COAX SW」「A: OFF B: ON」を刻印。
- ネジ: 基板 M3×6 タッピング ×4、フタ M3×8 タッピング ×2（ボスは左右の壁の中ほど）。F-J は付属ナットで内側から固定し、GND は M10 丸端子をナットに挟んで J4 へ。
- 寸法は `coax_relay_case.scad` の先頭のパラメータで調整（`sock_top`（ソケット高さ）, `led_z`, `fj_d`, `fj_flat`, `gap_f` など）。
- `overlay.scad` は KiCad の部品配置（`pcb_real.scad`、`hardware/scripts/gen_pcb_real.py` で生成）をケースに重ねて干渉を確認するためのファイル。`which=1〜3` でケース・フタと部品の重なりを出力できる（rev0.3 では重なりなし）。

## KiCad design hardware/coax_relay.kicad_pcb

Parts:
C1: 100uF 25V; CP_Radial_D6.3mm_P2.50mm
C2, C3: 0.1uF; C_Disc_D3.0mm_W2.0mm_P2.50mm
D1, D2: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal
F1: MF-R050 0.5A; Fuse_Bourns_MF-R050_P5.10mm
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: MJ-179PH
J4: OUT to F-J; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
LED1: RED 3mm; LED_D3.0mm
Q1: 2SC1815; TO-92_Inline_Wide
Q2: IRFU9024N; TO-251-3_Vertical
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R4, R7: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: RP2040-Zero; RP2040-Zero_Socket

Connections:
+12V: C1.1, C2.1, D1.1 (K), Q2.3 (S), R3.1, R7.1
/GATE: Q1.2 (C), Q2.1 (G), R7.2
/LED_A: LED1.2 (A), R5.2
/OUT: D2.1 (K), J4.1, Q2.2 (D), R5.1
/Q_BASE: Q1.3 (B), R1.2, R2.1
/RELAY_DRV: R1.1, U1.12 (GP2)
/VIN_F: D1.2 (A), F1.2
/VIN_RAW: F1.1, J1.1
/VMON: C3.1, R3.2, R4.1, U1.7 (GP26)
GND: C1.2, C2.2, C3.2, D2.2 (A), J1.2, J4.2, LED1.1 (K), Q1.1 (E), R2.2, R4.2, U1.2 (GND)

Notes on the sheet:
同軸リレー制御基板 rev0.2 PC(Chrome) -USB- RP2040-Zero -GP2-> 12V出力 -> Fコネクタ → 同軸リレー
[1] 電源入力：DCジャック → ポリスイッチ0.5A(過電流) → 1N5819(逆接保護) → +12V
[2] 12V監視：47k/10k分圧(1/5.7) → GP26(ADC0)
[3] マイコン：RP2040-Zero（USB給電・Web Serial）
1×9ピンソケット2本に挿す。5V/3V3は未使用
[4] 12V出力スイッチ（ハイサイド）
GP2=H → Q1 ON → Q2ゲートがGNDへ → Q2 ON → OUT=12V（ANT B）
GP2=L/リセット中 → R2がQ1をOFF, R7がQ2をOFF → OUT=0V（ANT A）
[5] 出力：J4 → ケースのF-J（中心=12V／外側=GND）→ 同軸リレー
D2：リレーコイルの逆起電力を吸収 LED1：出力中に点灯
取付穴 M3 ×4

Board: 2 copper layers, 66.0 x 46.0 mm, 22 parts (0 on the bottom side), 10 nets.

## Code that names these connections

File hardware/scripts/gen_sch_wired.py (part):

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       ("power:GND", 130.81, 101.6, 0), ("power:GND", 205.74, GND_B, 0)]

# net labels (name, x, y, angle)
LABELS = [("VIN_RAW", 36.83, RAIL12, 0), ("VIN_F", 54.61, RAIL12, 0), ("VMON", 120.65, 60.96, 0),
          ("RELAY_DRV", 161.29, 101.6, 0), ("Q_BASE", 175.26, 101.6, 0), ("GATE", 194.31, 83.82, 0),
          ("OUT", 220.98, 96.52, 0), ("LED_A", 231.14, 109.22, 270)]

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